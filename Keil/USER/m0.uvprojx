# Keil uVision project m0.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: CMSDK_CM0 ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.7.1
  cpu: IRAM(0x20000000,0x00400000) IROM(0x00000000,0x00400000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: m0 +hex
  AfterMake: fromelf -cvf .\Objects\m0.axf --vhx --32x1 -o image.hex
  AfterMake: fromelf -cvf .\Objects\m0.axf -o image.txt
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\CORE;..\DEVICE;..\USER;..\MY_GAME
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c
  group CORE
    ../CORE/: handler.c startup_CM0DS.s system.c
  group DEVICE
    ../DEVICE/: camera.c key.c lcd.c led.c Retarget.c spi_flash.c systick.c timer.c uart.c malloc.c spriteRam.c pstwo.c
  group MY_GAME
    ../MY_GAME/: boom.c enemyBullet.c enemyPlane.c gameHitCheck.c gameInterFace.c myPlane.c makeMap.c
